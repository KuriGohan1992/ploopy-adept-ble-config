## config/boards/shields/adept_ble/Kconfig.defconfig
```kconfig
if SHIELD_ADEPT_BLE

config ZMK_KEYBOARD_NAME
    default "Ploopy Adept"

endif

config SPI
	default y
```
